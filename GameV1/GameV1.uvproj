# Keil uVision project GameV1.uvproj, settings and files
target GameV1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: GameV1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c ST7735.c joystick.c joystick.h bitmaps.c bitmaps.h hud.c hud.h Menu.c Menu.h display_consts.h display_funcs.c display_funcs.h game_consts.h random.h random.s game_vars.h game_vars.c game_task.h game_task.c game.c
